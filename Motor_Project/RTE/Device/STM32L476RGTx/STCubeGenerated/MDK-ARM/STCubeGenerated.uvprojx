# Keil uVision project STCubeGenerated.uvprojx, settings and files
target STCubeGenerated (ARM-ADS)
  device: STMicroelectronics
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  library: MicroLIB
  group 
    ./: 
software components: CMSIS:CORE 4.3.0
