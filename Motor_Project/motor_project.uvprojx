# Keil uVision project motor_project.uvprojx, settings and files
target Default (6220000::V6.22::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: motor_project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c include: .\Headers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Modules
    ./Source/: application.c controller.c peripherals.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Inc/: stm32l4xx_it.h
software components: CMSIS:CORE 6.1.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:Common 1.13.4, Device:STM32Cube HAL:Cortex 1.13.4, Device:STM32Cube HAL:DMA 1.13.4, Device:STM32Cube HAL:GPIO 1.13.4, Device:STM32Cube HAL:PWR 1.13.4, Device:STM32Cube HAL:RCC 1.13.4, Device:STM32Cube HAL:TIM 1.13.4, Device:Startup 1.3.2
